# Keil uVision project Blinky_Ctrl.uvprojx, settings and files
target TM4C123GH6PM (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky_Ctrl
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c include: .\HAL\LED;.\MCAL\DIO;.\MCAL\GPT;.\MCAL\Interrupt_control;.\MCAL\GPIO;.\MCAL\SysTick
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/Blinky/: blinky.c
  group HAL
    ./HAL/LED/: LEDConfig.c LEDConfig.h
  group MCAL
    ./MCAL/DIO/: DIO_driver.c DIO_driver.h
    ./MCAL/GPIO/: GPIO_driver.h GPIO_driver.c
    ./MCAL/GPT/: GPT_driver.c GPT_driver.h
    ./MCAL/Interrupt_control/: IntCtrl_driver.c IntCtrl_driver.h
    ./MCAL/SysTick/: SysTick_driver.c SysTick_driver.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
