# Keil uVision project USART_Driver.uvprojx, settings and files
target STM32F446RE (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART_Driver
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: UART_TEST.c
  group Inc
    ./: USART_Driver.h bsp.h RCC_CLOCK.h
    ../I2C_Driver/: gpio_driver.h
  group Src
    ./: USART_Driver.c bsp.c RCC_CLOCK.c
    ../I2C_Driver/: gpio_driver.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
