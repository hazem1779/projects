# Keil uVision project GPIO_Driver.uvprojx, settings and files
target Stm32f446re (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_Driver
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -mfloat-abi=soft
  asm misc: -mfloat-abi=soft
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: main.c BUTTON_LED_NOINT.c LED_TEST.c BUTTON_LED_INT.c
  group Src
    ./: gpio_driver.c bsb.c
  group Include
    ./: gpio_driver.h bsb.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
