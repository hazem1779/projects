# Keil uVision project I2C_driver.uvprojx, settings and files
target stm32f446re nucleo (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C_driver
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c include: C:\Users\hazem\AppData\Local\Arm\Packs\Keil\STM32F4xx_DFP\2.16.0\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./: I2c_Master_TX_TEST.c I2C_Master_RX_TEST.c Master_Receive_Test_IT.c
  group Src
    ./: I2C_Driver.c bsp.c
    ../GPIO_Driver/: gpio_driver.c
  group Inc
    ./: bsp.h I2C_Driver.h
    ../GPIO_Driver/: gpio_driver.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
